# Repository adspawn/savaco

File README.md:

# サバゲー進行システム (v2)

サバイバルゲーム（サバゲー）の進行（休憩→開始前→ゲーム中→終了）を自動化・見える化するシステムです。
管理者はタブレット等の「管理画面」で操作し、フィールドの「表示画面」（TV/プロジェクター）にゲーム状況をリアルタイム表示します。
各ポジションのボタン発火は M5Stack UNIT-C6L (Meshtastic) 経由でLoRa受信し、自動でゲーム進行に反映されます。

> v1からの主な変更点: LoRa通信をM5Stack UNIT-C6L (Meshtastic) 方式に統一し、UIをレイアウトから全面刷新しました。
> 音声ファイル（.wav）は別途作成予定のため、本バージョンにはまだ含まれていません（フォルダ構成のみ用意済み）。

## システム構成

```
[各ポジションの送信デバイス]         [受信PC]
 ESP32-C3 + UNIT-C6L(送信)          UNIT-C6L(USB接続) ── Node.jsサーバー ── Socket.IO ──┬─ 管理画面(admin)
   10秒長押しで発火 → Meshtastic                                                        └─ 表示画面(display)
   Detection Sensor で LoRa 通知
```

- 送信側は「10秒長押しでMeshtastic経由のLoRa通知を飛ばす」だけの単純なデバイス（`lora/firmware`参照）。
- 受信側はUNIT-C6LをサーバーPCにUSB接続するだけ。サーバーは `@meshtastic/core` でシリアルのパケットを受信し、
  テキストを解釈してゲーム状態を更新します。**LoRaの送信プロトコルを自前実装する必要はありません。**
  受信して届いたテキストをキャッチするだけで完結します（`server/lora.js` / `server/meshtasticBridge.mjs`）。

## セットアップ

1. 依存関係のインストール
   ```bash
   npm install
   ```
   > `@meshtastic/core` が `preinstall` で pnpm を要求し、環境によっては
   > `npx only-allow pnpm` の実行に失敗して `npm install` がエラーになることがあります。
   > その場合は `npm install --ignore-scripts` を使ってください（動作に問題ありません）。

2. 環境変数の設定
   ```bash
   cp .env.example .env
   ```
   `.env` を編集してポート番号・UNIT-C6LのCOMポート番号などを設定してください。

3. サーバー起動
   ```bash
   npm start
   ```
   開発中は `npm run dev`（nodemon）が便利です。

4. ブラウザでアクセス
   - 管理画面: http://localhost:3000/admin/
   - 表示画面: http://localhost:3000/display/

`NODE_ENV=development`（`.env`のデフォルト）の場合、Meshtastic通信は初期化されません。
実機なしで動作確認したい場合は、管理画面下部の「デバッグ情報」パネルにあるテスト信号ボタンで
LoRa受信相当の動作をシミュレートできます。

本番でMeshtastic受信を有効にするには `.env` の `NODE_ENV=production` にし、`SERIAL_PORT` を実際の
UNIT-C6LのCOMポートに設定してください。

## ゲーム進行フェーズ

1. **待機中 (waiting)** - 休憩時間・ルール・制限時間・チーム位置を設定
2. **休憩中 (interval)** - カウントダウン。残り時間に応じて音声アナウンス（音声ファイル未配置時はスキップ）
3. **ゲーム開始前 (pre-game)** - 各チームの準備完了を待機（手動チェック or Meshtasticボタン）。両チーム準備完了で自動進行も可
4. **ゲーム中 (in-game)** - 制限時間カウントダウン。フラッグ戦/攻防戦はボタン検知で即終了、無限復活戦はボタン回数をカウント
5. **ゲーム終了 (game-over)** - 結果表示・自動保存（`results/`に保存）。「新しいゲーム」で待機中へ

ルールは以下の3種類（`server/state.js`の`GAME_OPTIONS`で定義）:
- フラッグ戦 / 攻防戦: どちらかのチームのボタン検知で即ゲーム終了
- 無限復活戦: ボタン検知のたびにカウントし、時間切れで引き分け集計

## LoRa (Meshtastic) 連携

- 送信側ファームウェア: [`lora/firmware/esp32c3_unit_c6l_lora/esp32c3_unit_c6l_lora.ino`](lora/firmware/esp32c3_unit_c6l_lora/esp32c3_unit_c6l_lora.ino)
  （ESP32-C3 SuperMini + UNIT-C6L、ボタン10秒長押しで発火）
- ハードウェア構成・配線・Meshtastic設定（Detection Sensor等）の詳細は [`lora/README.md`](lora/README.md) を参照
- 受信側は `server/lora.js` が届いたテキストからポジション(A〜E)を解決し、現在のゲームフェーズに応じて
  「準備完了」または「ボタン押下」として処理します
- `LORA_NODE_MAP`（`.env`）でMeshtasticの短縮ノードID(例: `D0E4`)とポジションを紐付けます（現在5台構成、詳細は[`lora/README.md`](lora/README.md)）
- 受信パケットのRSSI/SNR（電波品質）は管理画面のデバッグパネルに表示されます

## 予約カレンダーの取得（他フィールドの予約人数）

各フィールドが公開している Google カレンダー（iCal）を取得し、予定のタイトルから **日ごとの予約人数** を AI で判定して保存します。
タイトルの書き方はフィールドごと・予定ごとにバラバラ（「2名　川崎様」「貸切　10〜20名　初心者パック1」「３〜４名」など）なので、
人数の判定は Claude に任せています。「初心者パック3」「ガン10」のようなレンタル数や、「30名様まで」のような定員は人数として数えません。

AI 判定には **Claude Code CLI（`claude -p`）** を使います。Pro プランでログインしていれば **API キーは不要** で、
Pro の利用枠の中で動きます。同じタイトル（例「2名様」）は1回しか判定せず、結果は `reservations/data/cache.json` に保存されるため、
毎日の実行で AI に送られるのは新しく追加・変更された予定だけです。

### 準備

1. Node.js 18 以上（`fetch` を使うため）
2. Claude Code をインストールし、Pro アカウントでログイン
   ```bash
   claude        # 初回はブラウザでログイン。ログインできたら /exit で終了
   ```
3. 対象フィールドを `reservations/fields.json` に追加（`icsUrl` は Google カレンダーの「iCal 形式の公開アドレス」）
   ```json
   [
     { "id": "itoshima-isgf", "name": "糸島ISGF", "icsUrl": "https://calendar.google.com/calendar/ical/.../public/basic.ics" }
   ]
   ```

### 実行

```bash
npm run reservations -- --all       # 初回: 過去分もすべて判定（糸島ISGFで約17回 claude を呼びます）
npm run reservations                # 通常: 直近30日以降の未判定分だけ判定
npm run reservations -- --dry-run   # 取得と件数確認だけ（AI を呼ばない）
```

その他のオプション: `--field <id>`（1フィールドだけ）、`--since 2026-01-01`、`--max-calls N`、`--ics <ファイル>`（ダウンロード済みの .ics を使う）。

Pro の利用上限に達した場合や、1回の実行で `RESERVATION_MAX_CALLS`（既定30回）を超えた場合は、そこで止まります。
判定済みの分は保存されているので、次回の実行で続きから処理されます。

### 出力

| ファイル | 内容 |
|---|---|
| `reservations/data/<id>/days.json` | 日ごとの集計（人数の最小〜最大、休業、貸切、満員、人数不明の件数、元の予定と判定結果） |
| `reservations/data/daily.csv` | 全フィールドの日ごとの集計（Excel でそのまま開けます） |
| `reservations/data/<id>/calendar.ics` | 取得した元データ |

`people_min` / `people_max` は「3〜4名」のような幅を考慮した合計です。`open_ended` は「10名様〜」のような上限なしの予約があること、
`unknown_people` は人数が書かれていない予約の件数を表します。

### 毎日 23:30 に自動実行する（Windows）

コマンドプロンプトで次を実行します（`C:\path\to\savaco` はこのフォルダの場所に置き換え）。

```bat
schtasks /Create /TN "SavacoReservations" /SC DAILY /ST 23:30 /TR "cmd /c cd /d C:\path\to\savaco && npm run reservations >> reservations\update.log 2>&1"
```

- Claude Code のログイン情報を使うため、タスクは **ログインしているユーザーで** 実行されます（上のコマンドの既定）。
- PC がスリープ中だと実行されません。「タスク スケジューラ」で該当タスクのプロパティ →「条件」→「タスクを実行するためにスリープを解除する」、
  「設定」→「スケジュールされた時刻にタスクを開始できなかった場合、すぐにタスクを実行する」をオンにしてください。
- `claude` が見つからないと出る場合は、`.env` の `CLAUDE_BIN` に `claude.exe` のフルパスを指定してください。

Mac / Linux の場合は `crontab -e` に `30 23 * * * cd /path/to/savaco && npm run reservations >> reservations/update.log 2>&1` を追加します。

## フォルダ構成

```
savacoV2/
├── server/            # Express + Socket.IO サーバー
│   ├── index.js        # エントリーポイント・APIルート
│   ├── state.js         # ゲーム状態管理（SSOT）
│   ├── socket.js         # Socket.IOイベント処理
│   ├── audioQueue.js      # 音声再生キュー・スケジューリング
│   ├── lora.js            # Meshtastic受信 → ゲーム状態反映
│   └── meshtasticBridge.mjs  # UNIT-C6Lシリアル受信ブリッジ
├── public/
│   ├── admin/           # 管理画面（タブレット等での操作用）
│   ├── display/         # 表示画面（TV/プロジェクター表示用）
│   └── assets/
│       ├── css/theme.css  # 共通デザインシステム
│       └── sounds/        # 音声ファイル配置場所（現状は空、README参照）
├── reservations/       # 他フィールドの予約カレンダー取得・AI 判定（npm run reservations）
│   ├── fields.json       # 対象フィールドと iCal URL
│   └── data/             # 判定結果の保存先（git 管理外）
├── lora/
│   ├── README.md         # ハードウェア構成・Meshtastic設定まとめ
│   └── firmware/          # 送信側ESP32-C3ファームウェア
└── results/              # ゲーム結果の自動保存先（JSON）
```

## 音声ファイルについて

音源は別途作成予定のため、`public/assets/sounds/` 配下には実ファイルがまだありません。
存在しないファイルは警告ログを出しつつスキップされるだけなので、音声なしでも進行システム自体は問題なく動作します。
必要なファイル名の一覧は [`public/assets/sounds/README.md`](public/assets/sounds/README.md) にまとめてあります。

## システム要件

- Node.js 16以上
- Windows（シリアル通信用。他OSでも`SERIAL_PORT`の指定形式を変えれば動作可能）

## KiCad design hardware/e220-lora-carrier/e220_carrier.kicad_pcb

File hardware/e220-lora-carrier/README.md:

# E220 LoRa Carrier v2（差し込み式・全部手はんだ）

**ESP32-C3 SuperMini** と **E220-900T22S(JP)-EV2（SMA付き評価ボード）** をピンソケットで差し込むキャリア基板です。
部品はすべてスルーホール品なので、はんだごてだけで組み立てられます。マイコンやLoRaが壊れても差し替えるだけで直せます。
JLCPCBには基板の製造だけを発注し、部品は自分で揃えます。

| 表面 | 裏面 |
|---|---|
|  |  |

- 回路図: [`docs/schematic.pdf`](docs/schematic.pdf)（PNG: [`docs/schematic.png`](docs/schematic.png)）
- 実装図: [`docs/assembly_top.pdf`](docs/assembly_top.pdf)　DRC: [`docs/drc_report.txt`](docs/drc_report.txt)
- 製造データ: `production/e220_carrier_gerber_jlcpcb.zip`　部品リスト: `production/parts_list.csv`

## 仕様
| 項目 | 内容 |
|---|---|
| 基板 | 72 × 64 mm、2層、1.6mm、M3穴×4、部品は全部スルーホール |
| マイコン | ESP32-C3 SuperMini（1x8ピンソケット×2に差し込み、ピン列の間隔15.24mm、USB-Cは基板上端） |
| LoRa | E220-900T22S(JP)-EV2（1x7ピンソケットに差し込み、SMAは基板右端からはみ出す向き） |
| 電源 | モバイルバッテリー → SuperMiniのUSB-C → 5V端子から各部へ（充電回路なし） |
| ボタン | 12mmタクトSW＋外付けボタン用XH 2P（並列接続） |
| 基板ブザー | 5V自励式電子ブザー 12mm（85dB）、2SC1815で駆動 |
| サイレン | MT3608昇圧モジュールで**24V**に昇圧 → TIP120で外付けピエゾサイレンをON/OFF（XH 2P） |
| LED | 5mm 緑・赤 |
| 拡張 | I2C用ピンヘッダ 1x4（GND, 3V3, SCL=IO9, SDA=IO8。0.96インチOLEDと同じ並び） |

## ピン割り当て（SuperMini）
| GPIO | 信号 | 接続先 |
|---|---|---|
| IO0 | BTN_IO | ボタン（10kでプルアップ、1kを直列） |
| IO1 | BUZ | 基板ブザー（Highで鳴る） |
| IO2 | — | 未使用（起動時に状態を見るピンなので空けています） |
| IO3 | SIREN | 24Vサイレン（Highで鳴る。起動中は100kのプルダウンでOFF） |
| IO4 | LED_G | 緑LED |
| IO5 | LORA_RXD | ESP32 TX → E220 RXD（UART1） |
| IO6 | LORA_TXD | E220 TXD → ESP32 RX（UART1） |
| IO7 | LORA_AUX | E220 AUX |
| IO8 | I2C_SDA | J3（SuperMini上の青LEDと共用） |
| IO9 | I2C_SCL | J3（SuperMini上のBOOTボタンと共用） |
| IO10 | LORA_M0 | E220 M0 |
| IO20 | LORA_M1 | E220 M1 |
| IO21 | LED_R | 赤LED（起動時のログ出力で一瞬点滅するが無害） |

E220-EV2: VCCは5Vから給電します（VCCの範囲は3.1〜5.5V。信号は3.3Vのまま）。
M0/M1はE220内部でプルアップされているため、電源を入れた直後は設定モード（1/1）です。ファームウェアで0/0にして通常モードにします。

## 部品リスト（1台分）と価格の目安
| 記号 | 部品 | 個数 | 目安 |
|---|---|---|---|
| A1 | ESP32-C3 SuperMini（ピンヘッダ付き）＋ 1x8ピンソケット×2 | 1 | 400〜600円 |
| A2 | E220-900T22S(JP)-EV2 ＋ 1x7ピンソケット | 1 | 1,980円 |
| A3 | MT3608 昇圧モジュール（形はどれでも可） | 1 | 100〜160円 |
| BZ1 | 電子ブザー 5V 自励式 12mm（足の間隔7.6mm） | 1 | 50〜100円 |
| Q1 | 2SC1815（GR）または同等品 ※足の並びがE-C-Bのもの | 1 | 10〜20円 |
| Q2 | TIP120（TO-220） | 1 | 50〜100円 |
| D1, D2 | 1N4148 | 2 | 数円 |
| R1, R2, R4 / R3 / R5, R6 / R7, R8 | 1/4Wカーボン抵抗 1kΩ / 10kΩ / 220Ω / 100kΩ | 8 | 数十円 |
| C1 / C4 | 電解コンデンサ 100µF 16V以上 / 47µF 35V以上 | 2 | 数十円 |
| C2, C3 | 積層セラミック 0.1µF（足の間隔5mm） | 2 | 数十円 |
| SW1 | タクトスイッチ 12mm | 1 | 20〜50円 |
| LED1, LED2 | LED 5mm 緑・赤 | 2 | 数十円 |
| J1, J2 | JST XH 2P ポスト（＋ハウジング） | 2 | 数十円 |
| J3 | ピンヘッダ 1x4（任意） | 1 | 数円 |
| 基板 | JLCPCB 10枚＋送料（1枚あたり） | 1 | 約250円 |

**10台分の目安:** E220-EV2を除くと約1.0〜1.3万円、E220-EV2（1,980円×10）を含めると約3万円です。
アンテナ、外付けサイレン、モバイルバッテリーは別に必要です。

## 組み立て手順
1. 背の低い部品から付けます：抵抗、ダイオード（帯がある側＝K）、セラミックコンデンサ、トランジスタ、LED（足の長い方＝＋＝四角パッドの反対側）、タクトSW、ブザー（＋＝四角パッド）、電解コンデンサ（＋を合わせる）、XHコネクタ、ピンソケット。
2. **MT3608モジュールは配線する前に、テスターを見ながら半固定抵抗を回して24Vに合わせます**（USB 5Vを入力して測定）。合わせたら半固定抵抗を接着剤などで固定します。
3. モジュールを両面テープで基板の枠内に貼り、IN+/IN−/OUT+/OUT−を短い線でパッドにつなぎます。
4. SuperMiniとE220-EV2を差し込みます（向きはシルクの「USB」と「M0〜GND」に合わせる）。EV2はSMA側が浮くので、スペーサーや両面テープで支えると安定します。
5. J2にサイレンをつなぎます（＋はシルクの「+」側＝1番ピン）。**必ずDC24V対応のサイレンを使ってください。**

## 注意点
- 電源はSuperMiniのUSB-Cからのみ供給します。サイレンが鳴っている間は5V側に0.3〜0.5A程度流れます（モバイルバッテリーなら十分）。
- Q1を2SC1815以外で代用する場合は、足の並びを確認してください（S8050などは並びが違います）。
- SuperMiniの外部給電用5V端子とUSBは同時に使えません。この基板はUSBから給電する前提で、5V端子はSuperMiniから外部への出力として使っています。
- 110dB級のサイレンを近くで鳴らすと耳を傷めます。
- 配線は信号0.4mm / 電源0.6〜0.8mm、クリアランス0.2mm以上。KiCadのDRCでクリアランス違反・未接続ともに0件です（残りはライブラリ表の設定警告と、シルクが基板端やパッドで切れる警告のみ）。

## JLCPCBへの発注
`production/e220_carrier_gerber_jlcpcb.zip` をアップロードし、2層 / 1.6mm / 数量10で注文します。PCB Assemblyは不要です。

## データの再生成
```bash
cd hardware/e220-lora-carrier/gen && ./build.sh
```
`gen/design.py`（回路）と `gen/placement.py`（配置）を元に、回路図・基板・製造データをすべて作り直します。

Parts:
A1: ESP32-C3 SuperMini; ESP32-C3_SuperMini_Socket
A2: E220-900T22S(JP)-EV2; E220-EV2_Socket
A3: MT3608 module -> 24V; MT3608_Module_Wired
BZ1: 5V active buzzer 12mm (85dB); Buzzer_12x9.5RM7.6
C1: 100uF 16V; CP_Radial_D6.3mm_P2.50mm
C2, C3: 0.1uF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C4: 47uF 35V; CP_Radial_D6.3mm_P2.50mm
D1, D2: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3
J1: EXT BUTTON (XH); JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J2: SIREN 24V (XH); JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J3: I2C (OLED); PinHeader_1x04_P2.54mm_Vertical
LED1: GREEN 5mm; LED_D5.0mm
LED2: RED 5mm; LED_D5.0mm
Q1: 2SC1815; TO-92_Inline_Wide
Q2: TIP120; TO-220-3_Vertical
R1, R2, R4: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R5, R6: 220; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R7, R8: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW1: BUTTON 12mm; SW_PUSH-12mm

Connections:
+3V3: A1.3 (3V3), J3.2, R3.1
+5V: A1.1 (5V), A2.6 (VCC), A3.1 (IN+), BZ1.1 (+), C1.1, C2.1, D1.1 (K)
+24V: A3.3 (OUT+), C4.1, D2.1 (K), J2.1
BTN: C3.1, J1.1, R3.2, R4.1, SW1.1
BTN_IO: A1.8 (IO0), R4.2
BUZ: A1.7 (IO1), R1.1, R7.1
BUZ_B: Q1.3 (B), R1.2
BUZ_N: BZ1.2 (-), D1.2 (A), Q1.2 (C)
GND: A1.2 (GND), A2.7 (GND), A3.2 (IN-), A3.4 (OUT-), C1.2, C2.2, C3.2, C4.2, J1.2, J3.1, LED1.1 (K), LED2.1 (K), Q1.1 (E), Q2.3 (E), R7.2, R8.2, SW1.2
I2C_SCL: A1.13 (IO9 (BOOT/SCL)), J3.3
I2C_SDA: A1.12 (IO8 (LED/SDA)), J3.4
LED_G: A1.4 (IO4), R5.1
LED_G_A: LED1.2 (A), R5.2
LED_R: A1.16 (IO21/TX0), R6.1
LED_R_A: LED2.2 (A), R6.2
LORA_AUX: A1.11 (IO7), A2.5 (AUX)
LORA_M0: A1.14 (IO10), A2.1 (M0)
LORA_M1: A1.15 (IO20/RX0), A2.2 (M1)
LORA_RXD: A1.9 (IO5), A2.3 (RXD)
LORA_TXD: A1.10 (IO6), A2.4 (TXD)
SIREN: A1.5 (IO3), R2.1, R8.1
SIREN_B: Q2.1 (B), R2.2
SIREN_N: D2.2 (A), J2.2, Q2.2 (C)

Notes on the sheet:
1. モジュール（ESP32-C3 SuperMini / E220-EV2、ソケット差し込み）
2. ボタン / LED
3. 基板ブザー（5V 電子ブザー 85dB）
4. 24V昇圧（MT3608モジュール）＋ 外付けサイレン
NOTES
1. 給電はモバイルバッテリー→SuperMiniのUSB-C。5V端子か らE220(VCC)、ブザー、昇圧モジュールへ供給。
2. MT3608モジュールは配線でIN/OUTパッドに接続し、両面テープ で固定。半固定抵抗を24Vに合わせてから接続。
3. サイレンは DC24V 対応品を使用（12V専用品は不可）。IO3= Hで鳴動、起動中は100kでOFF。
4. E220のM0/M1は内部プルアップ。起動直後は設定モード(1/1) 、ファームで0/0にして通常モード。
5. IO8/IO9はSuperMini上のLED/BOOTと共用。I2C (OLED等)用にJ3へ出しています。

Board: 2 copper layers, 72.0 x 64.0 mm, 30 parts (0 on the bottom side), 23 nets.

File hardware/e220-lora-carrier/production/parts_list.csv:

部品,値,記号,1台あたり個数
ESP32-C3 SuperMini（ピンヘッダ付き）＋ 1x8ピンソケット×2,ESP32-C3 SuperMini,A1,1
E220-900T22S(JP)-EV2 ＋ 1x7ピンソケット,E220-900T22S(JP)-EV2,A2,1
MT3608 昇圧モジュール（半固定抵抗で24Vに調整）,MT3608 module -> 24V,A3,1
電子ブザー（自励式）5V 12mm ピッチ7.6mm,5V active buzzer 12mm (85dB),BZ1,1
電解コンデンサ 100uF 16V以上,100uF 16V,C1,1
積層セラミック 0.1uF,0.1uF,C2 C3,2
電解コンデンサ 47uF 35V以上,47uF 35V,C4,1
1N4148,1N4148,D1 D2,2
XHコネクタ 2P（外付けボタン用、任意）,EXT BUTTON (XH),J1,1
XHコネクタ 2P（サイレン用）,SIREN 24V (XH),J2,1
ピンヘッダ 1x4（任意）,I2C (OLED),J3,1
LED 5mm 緑,GREEN 5mm,LED1,1
LED 5mm 赤,RED 5mm,LED2,1
2SC1815 (GR) または同等品,2SC1815,Q1,1
TIP120（ダーリントン 60V 5A）,TIP120,Q2,1
カーボン抵抗 1/4W,1k,R1 R2 R4,3
カーボン抵抗 1/4W,10k,R3,1
カーボン抵抗 1/4W,220,R5 R6,2
カーボン抵抗 1/4W,100k,R7 R8,2
タクトスイッチ 12mm,BUTTON 12mm,SW1,1
ネジ・スペーサー M3,,H1-H4,4

## KiCad design hardware/e220-lora-node/e220_lora.kicad_pcb

File hardware/e220-lora-node/README.md:

# E220 LoRa Node（E220-900T22S(JP) + ESP32-C3）

920MHz LoRa モジュール **E220-900T22S(JP)** と **ESP32-C3** を載せた、ボタン・大音量ブザー・LED 付きの
LoRa 通信基板です。JLCPCB で基板製造と部品実装（PCBA）を発注できるよう、全部品を
**LCSC 在庫品（2026-11-13 時点で全品番在庫ありを確認済み）** から選定しています。

| 表面 | 裏面 |
|---|---|
|  |  |

- 回路図: [`docs/schematic.pdf`](docs/schematic.pdf)（PNG: [`docs/schematic.png`](docs/schematic.png)）
- 実装図（部品番号入り）: [`docs/assembly_top.pdf`](docs/assembly_top.pdf)
- DRC結果: [`docs/drc_report.txt`](docs/drc_report.txt)
- KiCad 7 プロジェクト: `e220_lora.kicad_pro` / `.kicad_sch` / `.kicad_pcb`（KiCad 7 以降で開けます）

## 仕様

| 項目 | 内容 |
|---|---|
| 基板 | 60 × 76 mm、2層、1.6mm、M3穴×4、部品はすべて表面（片面実装） |
| MCU | ESP32-C3-WROOM-02-N4（Wi-Fi/BLE、USB直結で書き込み可・USBシリアル変換IC不要） |
| LoRa | E220-900T22S(JP)、UART接続（M0/M1/AUX もGPIO接続）、アンテナは SMA（基板上）またはモジュールのIPEX |
| ボタン | 基板上タクトSW（SW4）＋外付けボタン用 JST-XH 2P（J4、並列接続。アーケードボタン等を配線可） |
| ブザー | ①基板上 MLT-8530 電磁ブザー（80dB、PWMで音程・パターン可変）<br>②**12V昇圧出力（J5）で外付けピエゾサイレン（100dB級）を駆動** ← 最大音量用 |
| LED | 緑・赤（GPIO制御）、充電中（赤）・満充電（緑） |
| 電源 | USB-C 5V、または 1S LiPo（JST-PH 2P）。基板上で充電（TP4056、約580mA）、電源スライドSW、3.3V LDO |
| 電池電圧監視 | VSW/2 を ADC（IO0）で測定 |

### 「可能な限り大音量」について
基板に載る（JLCPCBで実装できる）ブザーは 85dB 級が上限なので、2段構えにしています。

1. **基板上 MLT-8530（80dB @10cm）**: 2.7kHz 付近のPWMで最も大きく鳴ります。確認音・操作音向け。
2. **J5: 12.6V 出力（MT3608 昇圧 + AO3400 ローサイドSW）**: 市販の「12V 圧電サイレン / 電子ブザー（95〜110dB）」を
   XHコネクタで接続します。フィールドで本当に聞こえる音が必要な場合はこちら。
   - 鳴らし方: `SIREN_EN(IO10)=H` で昇圧ON → `SIREN_PWM(IO20)=H`（またはPWMで断続音）。待機中は両方Lにすると昇圧が止まり電池を消費しません。
   - 12Vサイレンは概ね 20〜60mA。LiPo側では 0.3〜0.5A 程度流れるので、500mAh以上の電池を推奨。

## ESP32-C3 ピン割り当て

| GPIO | 信号 | 接続先 / 備考 |
|---|---|---|
| IO0 | BAT_ADC | 電池電圧(VSW)の1/2（ADC1_CH0） |
| IO1 | BTN_IO | メインボタン（SW4 / J4、10kプルアップ、ディープスリープ復帰可） |
| IO2 | LORA_M1 | E220 M1（ストラップピンのため10kプルアップ） |
| IO3 | LORA_AUX | E220 AUX（100nF、復帰トリガ可） |
| IO4 | LORA_M0 | E220 M0 |
| IO5 | LORA_TXD | E220 TXD → ESP32 RX（UART1） |
| IO6 | LED_G | 緑LED |
| IO7 | BUZ | 基板上ブザー（AO3400経由、PWM） |
| IO8 | LORA_RXD | ESP32 TX（UART1）→ E220 RXD（ストラップピン、10kプルアップ） |
| IO9 | BOOT | BOOTボタン |
| IO10 | SIREN_EN | 12V昇圧 ON/OFF（100kプルダウン） |
| IO18/19 | USB D-/D+ | USB-C（書き込み・シリアル） |
| IO20 | SIREN_PWM | 外付けサイレンのSW（100kプルダウン。起動時は入力なので誤鳴動しない） |
| IO21 | LED_R | 赤LED（起動ログで一瞬点滅するが無害） |

E220 のモード: M1/M0 = 0/0 通常、0/1 WOR送信、1/0 WOR受信、1/1 設定/スリープ（データシート Rev2.1.2）。

## JLCPCB への発注手順

`production/` のファイルを使います。

1. **PCB**: JLCPCB の PCB 注文画面に `production/e220_lora_gerber_jlcpcb.zip` をアップロード
   （2層 / 1.6mm / 他はデフォルトでOK）。
2. **PCB Assembly** をON（Top Side）。
3. BOM に `production/e220_lora_bom_jlcpcb.csv`、CPL に `production/e220_lora_cpl_jlcpcb.csv` を指定。
4. 部品確認画面で **部品の向き（回転）をプレビューで必ず確認** してください。
   SOT-23系は補正済みですが、JLCPCB側のフットプリント原点・向きとの差は最終的に画面上で確認するのが確実です。
5. E220-900T22S(JP) は **LCSC取扱いがないためBOMに含めていません（U5は未実装で届きます）**。
   手はんだ（端面スルーホールなので手はんだ可）か、JLCPCB のグローバルソーシング / 委託部品で供給してください。

### 部品について
- 基本部品（Basic）20品番、拡張部品（Extended）12品番。拡張部品は1品番ごとにJLCPCBの段取り費が掛かります。
- スルーホール部品（J2 電池コネクタ、J4/J5 XH、J3 SMA）もBOMに入っています。手はんだにする場合は
  BOM/CPLの該当行を削除してから発注してください。
- J3（SMA）は任意です。E220モジュール上のIPEXにピグテールでアンテナを付けるなら不要。**ANT端子とIPEXの同時使用はしないこと。**

| Ref | 部品 | LCSC | 区分 |
|---|---|---|---|
| U4 | ESP32-C3-WROOM-02-N4 | C2934560 | Extended |
| U5 | E220-900T22S(JP) | — | 手配・手はんだ |
| U2 | TP4056 (ESOP-8) | C16581 | Extended |
| U3 | AP2112K-3.3 | C51118 | Extended |
| U6 | MT3608 | C84817 | Extended |
| U1 | USBLC6-2SC6 | C7519 | Extended |
| Q1 | AO3401A | C15127 | Basic |
| Q2,Q3 | AO3400A | C20917 | Basic |
| D1,D3 | SS34 | C8678 | Basic |
| D2,D4 | 1N4148W | C81598 | Basic |
| L1 | SWPA4030S100MT 10uH | C38117 | Extended |
| BZ1 | MLT-8530 | C94599 | Extended |
| J1 | USB-C TYPE-C-31-M-12 | C165948 | Extended |
| J2 | JST S2B-PH-K-S | C173752 | Extended |
| J3 | SMA BWSMA-KE-Z001 | C496549 | Extended |
| J4,J5 | JST B2B-XH-A | C158012 | Extended |
| SW1 | MSK12C02 スライドSW | C431541 | Extended |
| SW2-4 | TS-1187A タクトSW | C318884 | Basic |
| LED1,4 / LED2,3 | KT-0603G / KT-0603R | C12624 / C2286 | Extended / Basic |
| R, C | 0603/0805/1206 チップ部品 | BOM参照 | Basic |

## 設計メモ・注意点
- **E220 給電**: VCC（10番）に VSW（電池 3.0〜4.2V / USB時 約4.7V）を供給。VDD（15番）は未接続（内部LDO出力）。
  データシート推奨どおり AUX-GND 間に100nF。RF側（1〜3, 20〜22番）は GND ベタに接続。
- **ESP32 アンテナ**: 基板上端に配置し、アンテナ下は表裏とも銅箔なし（キープアウト）。
- **電池コネクタ極性**: J2 は pin1 = +（シルクの +/-）。JST-PH付きLiPoは製品により極性が逆のものがあるので必ず確認。保護回路付きLiPoを使用してください。
- 充電電流は R3=2kΩ で約580mA。小容量電池なら R3 を大きく（例: 3.3kΩ≒350mA）。
- 電源SW（SW1）はシステム側のみ切ります。OFFでもUSBを挿せば充電されます。
- 配線: 信号0.25mm / 電源0.4〜0.6mm、クリアランス0.15mm以上、ビア0.6/0.3mm（JLCPCB標準仕様内）。
  KiCad の DRC でクリアランス違反・未接続ともに0件（残りはライブラリ表の設定警告と、E220端面パッドにかかる外形シルクの警告のみ）。

## データの再生成
回路・部品・配置はすべてスクリプトから生成しています（KiCad 7 + Python/numpy）。

```bash
cd hardware/e220-lora-node/gen && ./build.sh
```

- `gen/design.py` … 部品・LCSC番号・ネット（回路の元データ）
- `gen/placement.py` … 基板上の部品配置
- `gen/footprints.py` … E220（データシートの推奨フットプリントから作図）と、LCSC部品のフットプリント（EasyEDA公開データから変換）
- `gen/router.py` … 自動配線（2層グリッドA*）。USB-C部は手引きパターン
- `gen/make_production.py` … JLCPCB用ガーバー/BOM/CPL

KiCad で手直しする場合は、`.kicad_pcb` を直接編集してかまいません（再生成すると上書きされる点に注意）。

## 参考
- E220-900T22S(JP) データシート Rev2.1.2（CLEALINK）: ピン配置（3.1章）、推奨フットプリント（図51）
- ESP32-C3-WROOM-02 データシート（Espressif）

Parts:
BZ1: MLT-8530 (80dB); Buzzer_MLT-8530; LCSC C94599
C1, C2, C3, C4, C10, C14: 10uF; C_0805_2012Metric; LCSC C15850
C5, C7: 10uF; C_0603_1608Metric; LCSC C19702
C6, C8, C11, C12, C13: 100nF; C_0603_1608Metric; LCSC C14663
C9: 1uF; C_0603_1608Metric; LCSC C15849
C15: 22uF; C_1206_3216Metric; LCSC C12891
D1, D3: SS34; D_SMA; LCSC C8678
D2, D4: 1N4148W; D_SOD-123; LCSC C81598
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3
J1: USB-C (TYPE-C-31-M-12); USB_C_Receptacle_HRO_TYPE-C-31-M-12; LCSC C165948
J2: BATTERY 1S LiPo (JST PH); JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal; LCSC C173752
J3: SMA (BWSMA-KE-Z001); SMA_BWSMA-KE-Z001; LCSC C496549
J4: EXT BUTTON (XH); JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical; LCSC C158012
J5: SIREN 12V (XH); JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical; LCSC C158012
L1: 10uH 1.5A; L_Sunlord_SWPA4030S; LCSC C38117
LED1: GREEN; LED_0603_1608Metric; LCSC C12624
LED2: RED; LED_0603_1608Metric; LCSC C2286
LED3: RED (CHG); LED_0603_1608Metric; LCSC C2286
LED4: GREEN (FULL); LED_0603_1608Metric; LCSC C12624
Q1: AO3401A; SOT-23; LCSC C15127
Q2, Q3: AO3400A; SOT-23; LCSC C20917
R1, R2: 5.1k; R_0603_1608Metric; LCSC C23186
R3: 2k; R_0603_1608Metric; LCSC C22975
R4, R5, R14: 1k; R_0603_1608Metric; LCSC C21190
R6, R7, R8, R17, R20, R21: 100k; R_0603_1608Metric; LCSC C25803
R9, R10, R11, R12, R13, R19: 10k; R_0603_1608Metric; LCSC C25804
R15: 100Ω; R_0603_1608Metric; LCSC C22775
R16: 470Ω; R_0603_1608Metric; LCSC C23179
R18: 200k; R_0603_1608Metric; LCSC C25811
SW1: POWER (MSK12C02); SW_MSK12C02; LCSC C431541
SW2: RESET; SW_TS-1187A; LCSC C318884
SW3: BOOT; SW_TS-1187A; LCSC C318884
SW4: BUTTON; SW_TS-1187A; LCSC C318884
U1: USBLC6-2SC6; SOT-23-6; LCSC C7519
U2: TP4056; ESOP-8_TP4056; LCSC C16581
U3: AP2112K-3.3; SOT-23-5; LCSC C51118
U4: ESP32-C3-WROOM-02-N4; ESP32-C3-WROOM-02; LCSC C2934560
U5: E220-900T22S(JP); E220-900T22S_JP
U6: MT3608; SOT-23-6; LCSC C84817

Connections:
+3V3: C5.1, C7.1, C8.1, R9.1, R10.1, R11.1, R12.1, R13.1, U3.5 (VOUT), U4.1 (3V3)
ANT: J3.1 (In), U5.21 (ANT)
BAT_ADC: C6.1, R7.2, R8.1, U4.18 (IO0/ADC1_0)
BOOT: R10.2, SW3.1, U4.8 (IO9/BOOT)
BTN: C13.1, J4.1, R13.2, R14.1, SW4.1
BTN_IO: R14.2, U4.17 (IO1/ADC1_1)
BUZ: Q2.1 (G), R17.1, U4.6 (IO7)
BUZ_N: BZ1.2 (-), D2.2 (A), Q2.3 (D)
CC1: J1.A5 (CC1), R1.1
CC2: J1.B5 (CC2), R2.1
CHG_PROG: R3.1, U2.2 (PROG)
CHRG_N: LED3.1 (K), U2.7 (~CHRG)
EN: C9.1, R9.2, SW2.1, U4.2 (EN)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.2, J3.2 (Ext), J4.2, LED1.1 (K), LED2.1 (K), Q2.2 (S), Q3.2 (S), R1.2, R2.2, R3.2, R6.2, R8.2, R17.2, R19.2, R20.2, R21.2, SW2.2, SW3.2, SW4.2, U1.2 (GND), U2.1 (TEMP), U2.3 (GND), U2.9 (GND), U3.2 (GND), U4.9 (GND), U4.19 (GND), U5.1 (GND), U5.2 (GND), U5.3 (GND), U5.4 (GND), U5.11 (GND), U5.13 (GND), U5.19 (GND), U5.20 (GND), U5.22 (GND), U6.2 (GND)
LEDC_A: LED3.2 (A), R4.2
LEDS_A: LED4.2 (A), R5.2
LED_G: R15.1, U4.5 (IO6)
LED_G_A: LED1.2 (A), R15.2
LED_R: R16.1, U4.12 (IO21/U0TXD)
LED_R_A: LED2.2 (A), R16.2
LORA_AUX: C12.1, U4.15 (IO3/ADC1_3), U5.9 (AUX)
LORA_M0: U4.3 (IO4), U5.5 (M0)
LORA_M1: R12.2, U4.16 (IO2 (strap)), U5.6 (M1)
LORA_RXD: R11.2, U4.7 (IO8 (strap)), U5.7 (RXD)
LORA_TXD: U4.4 (IO5), U5.8 (TXD)
MT_FB: R18.2, R19.1, U6.3 (FB)
MT_SW: D3.2 (A), L1.2, U6.1 (SW)
SIREN_EN: R20.1, U4.10 (IO10), U6.4 (EN)
SIREN_N: D4.2 (A), J5.2, Q3.3 (D)
SIREN_PWM: Q3.1 (G), R21.1, U4.11 (IO20/U0RXD)
STDBY_N: LED4.1 (K), U2.6 (~STDBY)
USB_DN: J1.A7 (D-), J1.B7 (D-), U1.3 (I/O2), U1.4 (I/O2), U4.13 (IO18/USB_D-)
USB_DP: J1.A6 (D+), J1.B6 (D+), U1.1 (I/O1), U1.6 (I/O1), U4.14 (IO19/USB_D+)
V12: C15.1, D3.1 (K), D4.1 (K), J5.1, R18.1
VBAT: C2.1, J2.1, Q1.3 (D), U2.5 (BAT)
VBUS: C1.1, D1.2 (A), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), Q1.1 (G), R4.1, R5.1, R6.1, U1.5 (VBUS), U2.4 (VCC), U2.8 (CE)
VSW: BZ1.1 (+), C4.1, C10.1, C11.1, C14.1, D2.1 (K), L1.1, R7.1, SW1.1 (A), U3.1 (VIN), U3.3 (EN), U5.10 (VCC), U6.5 (IN)
VSYS: C3.1, D1.1 (K), Q1.2 (S), SW1.2 (B)

Notes on the sheet:
1. USB-C 入力 / ESD保護
2. Li-ion 充電 (TP4056, 約580mA)
3. 電源パス / 電源SW / 3.3V LDO / 電池電圧監視
4. ESP32-C3 (WROOM-02)
5. LoRa E220-900T22S(JP) 920MHz
6. ボタン / LED
7. 基板ブザー (MLT-8530, 80dB)
8. 12V昇圧 + 外付けサイレン (100dB級)
NOTES
1. E220-900T22S(JP): LCSC取扱いなし → JLCP CBでは未実装(DNP)。手はんだ、またはJLCPCB委託部品として 供給。
2. E220 VCC(10)はVSW(3.0〜4.7V)から給電。VDD (15)は未接続(内部LDO出力)。AUXに100nF(データシート 推奨)。
3. J3 SMAは任意。モジュールのIPEXコネクタ+ピグテールでも可。 ANTとIPEXを同時に使わないこと。
4. 外付けサイレンはSIREN_EN=H(昇圧ON)の後にSIREN_P WM=Hで鳴動。待機時は両方Lで昇圧停止。
5. J2電池コネクタの極性はバッテリーにより逆の製品があるので必ず確認 (pin1=+)。保護回路付きLiPoを使用。

Board: 2 copper layers, 60.0 x 76.0 mm, 68 parts (0 on the bottom side), 38 nets.

File hardware/e220-lora-node/production/e220_lora_bom_jlcpcb.csv:

Comment,Designator,Footprint,LCSC Part #
MLT-8530 (80dB),BZ1,Buzzer_MLT-8530,C94599
10uF,"C1,C2,C3,C4,C10,C14",C_0805_2012Metric,C15850
10uF,"C5,C7",C_0603_1608Metric,C19702
100nF,"C6,C8,C11,C12,C13",C_0603_1608Metric,C14663
1uF,C9,C_0603_1608Metric,C15849
22uF,C15,C_1206_3216Metric,C12891
SS34,"D1,D3",D_SMA,C8678
1N4148W,"D2,D4",D_SOD-123,C81598
USB-C (TYPE-C-31-M-12),J1,USB_C_Receptacle_HRO_TYPE-C-31-M-12,C165948
BATTERY 1S LiPo (JST PH),J2,JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal,C173752
SMA (BWSMA-KE-Z001),J3,SMA_BWSMA-KE-Z001,C496549
EXT BUTTON (XH),J4,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,C158012
SIREN 12V (XH),J5,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,C158012
10uH 1.5A,L1,L_Sunlord_SWPA4030S,C38117
GREEN,LED1,LED_0603_1608Metric,C12624
RED,LED2,LED_0603_1608Metric,C2286
RED (CHG),LED3,LED_0603_1608Metric,C2286
GREEN (FULL),LED4,LED_0603_1608Metric,C12624
AO3401A,Q1,SOT-23,C15127
AO3400A,"Q2,Q3",SOT-23,C20917
5.1k,"R1,R2",R_0603_1608Metric,C23186
2k,R3,R_0603_1608Metric,C22975
1k,"R4,R5,R14",R_0603_1608Metric,C21190
100k,"R6,R7,R8,R17,R20,R21",R_0603_1608Metric,C25803
10k,"R9,R10,R11,R12,R13,R19",R_0603_1608Metric,C25804
100Ω,R15,R_0603_1608Metric,C22775
470Ω,R16,R_0603_1608Metric,C23179
200k,R18,R_0603_1608Metric,C25811
POWER (MSK12C02),SW1,SW_MSK12C02,C431541
RESET,SW2,SW_TS-1187A,C318884
BOOT,SW3,SW_TS-1187A,C318884
BUTTON,SW4,SW_TS-1187A,C318884
USBLC6-2SC6,U1,SOT-23-6,C7519
TP4056,U2,ESOP-8_TP4056,C16581
AP2112K-3.3,U3,SOT-23-5,C51118
ESP32-C3-WROOM-02-N4,U4,ESP32-C3-WROOM-02,C2934560
MT3608,U6,SOT-23-6,C84817
